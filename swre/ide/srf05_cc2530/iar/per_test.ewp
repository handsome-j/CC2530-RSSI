# IAR project per_test.ewp, settings and files
configuration srf05_cc2530 (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: chip=2530
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../source/Components/utils; ../../../source/Components/common; ../../../source/Components/basicrf; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/Components/common/cc8051; ../../../source/Components/targets/srf05_soc; ../../../source/Components/radios/cc2530
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\iar\8051\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
  group application
    ../../../source/apps/per_test/: per_test.c per_test.h per_test_menu.c per_test_menu.h
  group basic rf
    ../../../source/components/basicrf/: basic_rf.c basic_rf.h
  group hal/common
    ../../../source/components/common/cc8051/: hal_cc8051.h
    ../../../source/components/common/: hal_defs.h hal_int.c hal_types.h
    ../../../source/components/targets/common/: hal_lcd_srf05.c
  group hal/interface
    ../../../source/components/targets/interface/: hal_assert.h hal_button.h hal_digio.h hal_int.h hal_joystick.h hal_lcd.h hal_led.h hal_mcu.h hal_timer_32k.h hal_uart.h
  group hal/rf
    ../../../source/components/targets/interface/: hal_rf.h
  group hal/rf/cc2530
    ../../../source/components/radios/cc2530/: adc.c adc.h clock.c clock.h hal_mcu.c hal_rf.c hal_timer_32k.c
  group hal/srf05_soc
    ../../../source/components/targets/srf05_soc/: hal_assert.c hal_board.c hal_board.h hal_button.c hal_digio.c hal_joystick.c hal_led.c
  group utilities
    ../../../source/components/utils/: util.c util.h util_buffer.c util_buffer.h util_lcd.c util_lcd.h
